## base_external/Config.in
```kconfig
menu "Project Base configuration"

source "$BR2_EXTERNAL_project_base_PATH/package/aesd-assignments/Config.in"

endmenu
```
